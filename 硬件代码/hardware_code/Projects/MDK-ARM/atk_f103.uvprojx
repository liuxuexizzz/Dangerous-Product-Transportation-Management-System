# Keil uVision project atk_f103.uvprojx, settings and files
target ATK-IDM750C (ARM-ADS)
  device: APM32F103ZE APEXMIC
  pack: APEXMIC.APM32F1xx_DFP.1.0.4
  cpu: IROM(0x08000000,0x00080000) IRAM(0x20000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: atk_f103 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ..\..\Drivers\CMSIS\Device\ST\STM32F1xx\Include;..\..\Drivers\STM32F1xx_HAL_Driver\Inc;..\..\Drivers\CMSIS\Include;..\..\Drivers\;..\..\User;..\..\Middlewares;..\..\Drivers\BSP\DHT11;..\..\Drivers\BSP\Switch;..\..\Drivers\BSP\Beep;..\..\Drivers\BSP\adc_dma
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Startup
    ../../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f103xe.s
  group User
    ../../User/: main.c stm32f1xx_it.c demo.c
    ../../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
  group Drivers/SYSTEM
    ../../Drivers/SYSTEM/delay/: delay.c
    ../../Drivers/SYSTEM/sys/: sys.c
    ../../Drivers/SYSTEM/usart/: usart.c
  group Drivers/STM32F1xx_HAL_Driver
    ../../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_sram.c stm32f1xx_ll_fsmc.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c
  group Drivers/BSP
    ../../Drivers/BSP/LED/: led.c
    ../../Drivers/BSP/LCD/: lcd.c
    ../../Drivers/BSP/KEY/: key.c
    ../../Drivers/BSP/ATK_IDM750C/: atk_idm750c.c atk_idm750c_uart.c
    ../../Drivers/BSP/ATK_MS6050/: atk_ms6050.c atk_ms6050.h atk_ms6050_iic.c atk_ms6050_iic.h
    ../../Drivers/BSP/ATK_MS6050/eMPL/: dmpKey.h dmpmap.h inv_mpu.c inv_mpu.h inv_mpu_dmp_motion_driver.c inv_mpu_dmp_motion_driver.h
    ../../Drivers/BSP/ATK_MO1218/: atk_mo1218.c atk_mo1218.h atk_mo1218_bin_msg.c atk_mo1218_bin_msg.h atk_mo1218_nmea_msg.c atk_mo1218_nmea_msg.h atk_mo1218_uart.c atk_mo1218_uart.h
    ../../Drivers/BSP/DHT11/: dht11.c dht11.h
    ../../Drivers/BSP/Switch/: switch.c switch.h
    ../../Drivers/BSP/Beep/: beep.c beep.h
    ../../Drivers/BSP/watersensor/: watersensor.c watersensor.h
    ../../Drivers/BSP/smokesensor/: smokesensor.c smokesensor.h
    ../../Drivers/BSP/fuelgassensor/: fuelgassensor.c fuelgassensor.h
    ../../Drivers/BSP/adc/: adc.c adc.h
    ../../Drivers/BSP/adc_dma/: adc_dma.c adc_dma.h
